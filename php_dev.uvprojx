# Keil uVision project php_dev.uvprojx, settings and files
target php_dev (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Peripheral_Devices
  c flags: Optim=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c include: .\Include;.\ek-tm4c123gxl;.\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./: bsp.c dev_buzzer.c dev_glcd.c dev_mpu.c dev_servomotor.c dev_steppermotor.c main.c misc.c php.c php_adc.c php_gpio.c php_i2c.c php_keypad.c php_lcd.c php_led.c php_pwm.c php_spi.c php_switch.c php_timer.c php_uart.c bsp.h core_cm4.h dev_buzzer.h dev_glcd.h dev_mpu.h dev_servomotor.h dev_steppermotor.h misc.h php.h php_adc.h php_gpio.h php_i2c.h php_keypad.h php_lcd.h php_led.h php_pwm.h php_spi.h php_switch.h php_timer.h php_uart.h tm4c_cmsis.h TM4C123GH6PM.h dev_rfid.h dev_rfid.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
